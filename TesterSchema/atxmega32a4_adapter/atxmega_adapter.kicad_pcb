# Repository yjek/wspolny_projekt

File README.md:

# wspolny_projekt
Bartoszkowo Yjkowe wypociny

## KiCad design TesterSchema/atxmega32a4_adapter/atxmega_adapter.kicad_pcb

Parts:
C1, C2, C5: 100n; C_0603_HandSoldering
C3, C4: 1µ; C_1206_HandSoldering
D1, D2, D3: RED; LED-0805
IC1: ATXMEGA32A4-M; QFN-44-1EP
L1: INDUCTOR_SMALL; Choke_SMD_1206_Handsoldering
P1: DIL40; DIP-40__600_ELL
Q1, Q2, Q3: BC817-40; sot23
R1, R2, R3, R4, R5, R6, R8: 10k; R_1206_HandSoldering
R7: 4k7; R_1206_HandSoldering
R9, R10, R11: 0R; R_1206_HandSoldering
R12, R13, R14: 200; R_0805_HandSoldering
U1: MCP1702T3302ECB; SOT-23

Connections:
+3.3V: C1.1, C2.1, C4.1, IC1.9 (VCC), IC1.19 (VCC), IC1.31 (VCC), L1.1, R12.1, R13.1, R14.1, U1.2 (VOUT)
+3.3VADC: C5.1, IC1.39 (AVCC), L1.2
/ADC_I: IC1.1 (AC5/ADC5/PA5), P1.36
/ADC_U: IC1.5 (ADC9/PB1), P1.40
/AREF: IC1.40 (AREFA/AC0/ADC0/PA0), P1.32
/BUZER: IC1.43 (AC3/ADC3/PA3), P1.34
/DB0: IC1.10 (SDA/~OC0ALS~/OC0A/PC0), P1.1
/DB1: IC1.11 (SCL/XCK0/OC0AHS/OC0B/PC1), P1.2
/DB2: IC1.12 (RXD0/~OC0BLS~/OC0C/PC2), P1.3
/DB3: IC1.13 (TXD0/OC0BHS/OC0D/PC3), P1.4
/DB4: IC1.14 (~SS~/~OC0CLS~/OC1A/PC4), P1.5
/DB5: IC1.15 (MOSI/XCK1/OC0CHS/OC1B/PC5), P1.6
/DB6: IC1.16 (MISO/RXD1/~OC0DLS~/PC6), P1.7
/DB7: IC1.17 (EVOUT/CLKOUT/SCK/TXD1/OC0DHS/PC7), P1.8
/E: IC1.2 (AC6/ADC6/PA6), P1.37
/NO_ADC: IC1.44 (AC4/ADC4/PA4), P1.35
/OW: IC1.41 (AC1/ADC1/PA1), P1.29
/PDI_DATA: IC1.34 (PDI_DATA), P1.27
/PWM_CHG: P1.19, Q3.3 (C), R4.1
/PWM_DSG: P1.18, Q2.3 (C), R2.1
/R/W: IC1.3 (AC0OUT/AC7/ADC7/PA7), P1.38
/RESET: IC1.35 (~RESET~/PDI_CLK), P1.9
/RS: IC1.4 (AREFB/ADC8/PB0), P1.39
/RXD: P1.14, R6.1
/SW1: IC1.42 (AC2/ADC2/PA2), P1.28
/SW2: IC1.24 (PD4/OC1A/~SS~), P1.17
/SW3: IC1.25 (PD5/OC1B/XCK1/MOSI), P1.20
/SW4: IC1.26 (PD6/RXD1/MISO), P1.21
/TXD: P1.15, Q1.3 (C), R1.1
/XTAL1: IC1.37 (PR1/XTAL1/TOSC1), R9.1
/XTAL2: IC1.36 (PR0/XTAL2/TOSC2), R10.1
AGND: C5.2, IC1.38 (GND), P1.31
GND: C1.2, C2.2, C3.2, C4.2, D3.2 (K), IC1.8 (GND), IC1.18 (GND), IC1.30 (GND), P1.11, Q1.2 (E), Q2.2 (E), Q3.2 (E), R7.1, U1.1 (GND)
unnamed: C3.1, R11.2, U1.3 (VIN)
unnamed: D1.1 (A), R12.2
unnamed: D1.2 (K), IC1.7 (DAC1/ACD11/PB3)
unnamed: D2.1 (A), R13.2
unnamed: D2.2 (K), IC1.6 (DAC0/ADC10/PB2)
unnamed: D3.1 (A), R14.2
unnamed: IC1.28 (PE0/OC0A/SDA), R3.2
unnamed: IC1.29 (PE1/OC0B/XCK0/SCL), R5.2
unnamed: IC1.32 (PE2/OC0C/RXD0), R6.2, R7.2
unnamed: IC1.33 (PE3/OC0D/TXD0), R8.1
unnamed: P1.12, R9.2
unnamed: P1.13, R10.2
unnamed: Q1.1 (B), R8.2
unnamed: Q2.1 (B), R3.1
unnamed: Q3.1 (B), R5.1
VCC: P1.10, R1.2, R2.2, R4.2, R11.1

Board: 2 copper layers, 55.0 x 20.0 mm, 29 parts (10 on the bottom side), 49 nets.

## KiCad design TesterSchema/Część fizyczna/v1.1/Tester ogniw v1.1 - Moduł mocy.kicad_pcb

Parts:
D1, D3: 1N4148; DO-35
D2: D_SCH; DO-8
F1, F2: F; BEZP-19MM-AMFGN
FT1, FT2: FT; PIN-2-I
J1: J2; bridge_3mm
K1: K10; IDE-V-10
K3: Zasilanie; ark500-2
K4: Badany AKU; ark500-2
R1, R2, R3, R4, R15, R16, R17, R25, R26, R27: 0R1; resistor-10W_9x49
R5, R7, R11: 10k; resistor-0207_7
R6, R12: Jeszcze nie wiem; resistor-0207_10
R8: 2k2; resistor-0207_7
R9, R10, R14: 1k5; resistor-0207_7
R13: 100k; resistor-0207_7
R18: 0R1; resistor-25W_17x29
R24: 100k; resistor-0207_10
T1: IRFP9140; TO-247AC_V_inv
T2: IRFP054N; TO-247AC_V_inv
T3, T4, T6: BC547; TO-92-B
T5, T7: T_PNP; TO-92-B

Connections:
/+18V: F1.1, K1.1, R1.1, R6.2, R12.2
/CHG: FT1.1, K1.4
/DSG: FT2.1, K1.6, R14.1
/I_bat: D2.A, K1.10, K4.2, R18.1
/NoDAC: K1.3, R5.1, R7.1, R11.1
/U_bat: D2.K, K1.8, K4.1, T1.D, T2.D
AGND: J1.1, K1.5, K1.7, K1.9
GND: F2.2, J1.2, K1.2, K3.2, R18.2, R24.2, T3.E, T4.E, T6.E, T7.C
unnamed 8: D1.K, R6.1; also elsewhere on the board
unnamed 9: D1.A, T3.C; also elsewhere on the board
unnamed 10: D3.A, T6.C; also elsewhere on the board
unnamed 11: D3.K, R12.1; also elsewhere on the board
unnamed: R5.2, T3.B
unnamed: R11.2, T6.B
unnamed: R14.2, T7.B
unnamed: R10.2, T5.C
unnamed 16: R8.2, R13.2, R17.2, T1.S, T5.E; also elsewhere on the board
unnamed: R7.2, T4.B
unnamed: R9.1, T5.B
unnamed: R8.1, R9.2, T4.C
unnamed: R3.2, R4.1
unnamed: R2.2, R15.1
unnamed: R1.2, R2.1
unnamed: R15.2, R16.1
unnamed: R25.2, R26.1
unnamed: R16.2, R17.1
unnamed: R26.2, R27.1
unnamed: R3.1, R27.2
unnamed: F1.2, K3.1
unnamed: FT2.2, R24.1, T2.G, T7.E
unnamed: F2.1, R4.2
unnamed 31: R25.1, T2.S; also elsewhere on the board
unnamed: FT1.2, R10.1, R13.1, T1.G

Notes on the sheet:
Te rezystory pozwolą pracować WO w szerszym zakresie napięć dzięki czemu zredukuje się stosunek sygnału do szumu.
Bezpiecznik po stronie źródła, żeby można było połączyć oba MOSFET'y drenami. W przypadku przepalenia bezp. po stronie drenu, nastąpiłoby zwarcie przez radiator.
Piny parzyste to sygnały a piny nieparzyste to masa. W takiej kolejności sygnały na szmacie będzą miedzy masami - namiastka ekranowania.
Dobrać rezystancję
Dobrać pojemność

Board: 2 copper layers, 182.0 x 75.0 mm, 42 parts (13 on the bottom side), 33 nets.

Other parts of the board:
PR1, PR2: 12V; ELEKTROMECH-PR-S40-DPDT

Their connections:
unnamed 8: PR1.E1; also elsewhere on the board
unnamed 9: PR1.E2; also elsewhere on the board
unnamed 10: PR2.E2; also elsewhere on the board
unnamed 11: PR2.E1; also elsewhere on the board
unnamed 16: PR1.S1; also elsewhere on the board
unnamed 31: PR2.S1; also elsewhere on the board

## KiCad design TesterSchema/Część fizyczna/v1.1/Tester ogniw v1.1 - Sterownik.kicad_pcb

Parts:
C1, C4, C6, C7, C10, C11, C22, C23, C26, C31, C33, C35: 100n
C2, C3: 27p
C8, C9, C12, C13, C27, C30: 10µ
C18, C19, C20, C25, C28, C29, C32: 1µ
C21, C24: 470µ
C34: 100µ
D1, D2: 1N4841
D3: Power
D4, D5, D6: 1N4148
DZ1: 4V1
K1: D-SUB-DE-9
K2: JTAG-ATMEL
K3: K20
K4: K10
L1: 100µH
L3: 100µ
P2: 500R
P3: 1k
P4: 100k
PR1: PR_DPDT
R1, R9, R11: 4k7
R2, R7, R10, R12, R19, R29: 47k
R3, R28: 10k
R4, R20, R22, R23: 10k; Tolerancja 1%
R5, R6: 680R
R8, R14: 22k
R21: 20k; Tolerancja 1%
R30: 3k9
R31: 1k
R32: 330
T1, T2: BC547
U1, U2: TL082
U3: RTCC
US1, US2, US4: DS18B20; TO-92
US3: MAX232
US5: 7805
US6: MCP1541
US7: ICL7660
X1: 1.8432MHz
uC1: ATMEGA16-PU; DIP-40

Connections:
+5VD: C4.1, C6.2, C7.1, C8.-, C10.2, C11.2, C24.+, C26.1, C33.2, D4.K, K2.4, K2.7, K3.20, L1.2, PR1.E1, R1.2, R2.1, R32.1, U3.2 (VDD), US1.3 (VDD), US2.3 (VDD), US3.16 (Vcc), US4.3 (VDD), US5.2, US6.3 (Vin), US7.8 (V+), uC1.10
-5VA: C23.2, C31.2, C34.-, C35.1, U1.4 (Vee), U2.4 (Vee), US7.5 (Vout)
/+18V: K4.1, L3.2
/ADC_I: C32.2, P4.2, P4.S, U1.1, uC1.36
/ADC_U: C28.2, DZ1.K, R29.1, uC1.40
/Buzzer: K3.7, uC1.34
/CHG: D5.A, K4.4, T1.C
/DB0: K3.15, uC1.1
/DB1: K3.14, uC1.2
/DB2: K3.13, uC1.3
/DB3: K3.12, uC1.4
/DB4: K3.11, uC1.5
/DB5: K3.10, uC1.6
/DB6: K3.9, uC1.7
/DB7: K3.8, uC1.8
/DSG: K4.6, PR1.B1, R6.1
/E: K3.16, uC1.37
/I_bat: K4.10, R12.2, R19.1, R20.2, R21.2
/MPF: U3.1 (MPF), uC1.16
/No_DAC: K4.3, R4.1, uC1.35
/OW: R1.1, US1.2 (DQ), US2.2 (DQ), US4.2 (DQ), uC1.29
/PWM_CHG: PR1.S2, R7.1, uC1.19
/PWM_DSG: PR1.S1, R10.2, uC1.18
/R/W: K3.17, uC1.38
/RESET: K2.6, R2.2, uC1.9
/RS: K3.18, uC1.39
/RXD: US3.12 (R1_OUT), uC1.14
/SCL: U3.3 (SCL), uC1.22
/SDA: U3.5 (SDA), uC1.23
/SW1: K3.1, uC1.28
/SW2: K3.2, uC1.17
/SW3: K3.3, uC1.20
/SW4: K3.4, uC1.21
/TCK: K2.1, uC1.24
/TDI: K2.9, uC1.27
/TDO: K2.3, uC1.26
/TMS: K2.5, uC1.25
/TXD: US3.11 (T1_IN), uC1.15
/U_bat: K4.8, R30.1
/VRef: C29.1, R28.2, uC1.32
AGND: C19.2, C20.2, C27.-, C28.1, C29.2, DZ1.A, K4.5, K4.7, K4.9, R9.1, R11.1, R31.2, U1.3 (+), U2.3 (+), US6.1 (Vss), uC1.31
GND: C1.1, C2.1, C3.1, C4.2, C6.1, C7.2, C9.+, C10.1, C11.1, C21.-, C22.2, C24.-, C26.2, C33.1, C34.+, C35.2, D3.K, K1.5, K2.2, K2.10, K3.19, K4.2, T1.E, T2.E, U3.4 (VSS), US1.1 (GND), US2.1 (GND), US3.15 (GND), US4.1 (GND), US5.3, US7.3 (GND), uC1.11
unnamed: R12.1, U2.5 (+)
unnamed: C1.2, L1.1, uC1.30
unnamed: C20.1, R10.1, R11.2, R14.2
unnamed: D3.A, R32.2
unnamed: C27.+, R28.1, US6.2 (Vout)
unnamed: C30.1, US7.2 (Cap+)
unnamed: P3.S, R29.2
unnamed: P3.1, R31.1
unnamed: P2.1, R21.1
unnamed: D4.A, PR1.E2, T2.C
unnamed: R4.2, T2.B
unnamed: C18.1, R8.2, U2.6 (-)
unnamed: PR1.B2, R3.1
unnamed: R3.2, T1.B
unnamed: C32.1, P2.S, P4.1, U1.2 (-)
unnamed: D1.K, R20.1, R22.1, U2.2 (-)
unnamed: C19.1, R7.2, R8.1, R9.2
unnamed: D5.K, R5.2
unnamed: D6.K, R6.2
unnamed: C18.2, R5.1, U2.7
unnamed: D1.A, D2.K, U2.1
unnamed: D2.A, R22.2, R23.2
unnamed: P2.2, R23.1
unnamed: C25.1, R14.1, U1.6 (-)
unnamed: R19.2, U1.5 (+)
unnamed: C25.2, D6.A, U1.7
unnamed: C13.+, US3.4 (C2+)
unnamed: C12.+, US3.1 (C1+)
unnamed: K1.7, K1.8
unnamed: K1.3, US3.13 (R1_IN)
unnamed: K1.4, K1.6
unnamed: K1.2, US3.14 (T1_OUT)
unnamed: C12.-, US3.3 (C1-)
unnamed: C13.-, US3.5 (C2-)
unnamed: C9.-, US3.6 (Vs-)
unnamed: C8.+, US3.2 (Vs+)
unnamed: P3.2, R30.2
unnamed: C30.2, US7.4 (Cap-)
unnamed: C2.2, X1.2, uC1.12
unnamed: C3.2, X1.1, uC1.13

Notes on the sheet:
V < 3,5V → LV: GND
Wzmacniacz błędu prądu rozładowania.
Wzmacniacz błędu prądu ładowania
Wzmacniacz
Prostownik linearyzowany
Złącza na termometry ds18b20 (typu molex naljepiej)
Piny parzyste to sygnały a piny nieparzyste to masa. W takiej kolejności sygnały na szmacie będzą miedzy masami - namiastka ekranowania.
Dolutować z diodą
Wstawić diodę prostowniczą w szereg z dławikiem.
zrobione
Tranzystor przesuwa napięcia sterowania 5V i zasilania sterowanego MOSFET-a 18V na gałęzi dodatniej.
Tranzystor pośredniczący w przesuwaniu napięć sterującego i zasilania sterowanego MOSFET-a niepotrzebny bo MOSFET znajduje się w gałęzi ujemnej (sterowany względem masy).
Zmienić dzielnik na max 3V dla Xmega. MCP ma 1024 albo 4096.

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
Board: 2 copper layers, 75.0 x 100.0 mm, 82 parts (0 on the bottom side), 81 nets.

## Commit log

2015-02-03 Usunięcie plików z kopii zapasowej
2015-02-03 usunięcie niepotrzebnych plików
2015-02-03 Zmiana nazw folderów
2015-02-03 Usunięcie starych folderów
2015-02-03 Update ustawień projektu
2015-02-03 usunięcie zbędnego syfu
2015-02-03 auktualnienie ustawień projektu
2015-02-03 Uaktualnienie projektu eclipse
2015-02-03 Zmiany w projekcie przejściówki (wykorzystanie elementów dostępnych w standardowych bibliotekach + zmiana footprintu atmego bo był zły :/ )
2015-02-04 Poprawa schematu płytki
2015-02-04 add libs
2015-02-04 Przesunięcie brakujących *.lib z AkuTester do TesterSchema
2015-02-04 add $ file to ignore list
2015-02-04 remove duplicated files
2015-02-05 poprawki płytki
2015-02-08 zmiany z adapterze
2015-02-09 Poprawa nazw warstw (naprawa błędu związanego z przejściem na nową wersję kicada)
2015-02-09 Poprawienie schematu Sterownika w związku z migracją na KiCAD2015 Poprawienie schematu Modułu Mocy w związku z migracją na KiCAD2015 i dodaniem clamp'a na wyjściu AKU
2015-02-09 dodanie _autosave do listy ignorowanych plików
2015-02-09 ignorelist update
2015-02-09 naprawa pliku PCB modułu mocy
2015-02-10 Naprawa repo
2015-02-10 naprawa biblioteki z rezystorami
2015-02-10 dodanie plików bakapu pcb do listy wykluczeń
2015-02-10 dodanie brakujących ściażek do modułu wykonawczego
2015-02-10 add metadata folder to ignore list
2015-02-10 update gitignore
2015-02-10 gitignore
2015-02-10 add libs (reverted from commit b10e9c0b998399a53f18e4da0b88fc3e09605f1e)
2015-02-12 Dodanie diody sygnalizującej zasilanie i 2 diodek pomocniczych
2015-02-12 usunięcie metadanych eclipse
2015-02-12 Usuniecie pierdół
2015-02-12 usunięcie nieużywanych plików
2015-02-12 zmiana ustawień projektu
2015-02-12 dodanie folderu z hexem do listy ignorowanych plików
2015-02-13 Dodany program testowy, oraz małe poprawki w płytce adaptera
2015-02-13 Zmiana kilku pierdół
2015-02-14 Dodanie folderu "Postprodukjca" i wygenerowanie odbitek do termotransferu.
2015-02-14 Dodanie folderu "Postprodukcja" do "atxmega32a4_adapter" i wygenerowanie odbitek do termotransferu.
2015-02-14 poprawienie płytki
2015-02-14 uaktualnienie wydruku
2015-02-14 małe poprawki
2015-02-14 Zmiana grubości krawędzi PCB w adapterze z 0,15 na 0,3
2015-02-14 Zmiana nazwy stabilizatore/ poprawki w adapeerze
2015-02-15 Wygenerowanie odbitek do termotransferu PDF i usunięcie plików postscript
